## Kconfig
```kconfig
menu "LDAC decoder"

    config LDAC_DECODER
        bool "Enable LDAC decoder"
        default n
        help
            LDAC decoder.

endmenu
```
